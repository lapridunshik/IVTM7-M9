# IAR project ivtm7-m9.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: CC430F5137 CC430F5137
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: Y:\Programs\Service\MSP430; Y:\Programs\Service\ARM\LPC
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: D:\Progs\ivtm-7m9my\lnkcc430F5137.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group main
    ./: define.h exch_main.c global_declaration.h global_var.c hal_pmm.c ini.c interrupts.c lcd_main.c lnkcc430F5137.xcl main.c printf.c RF1A.c RF_Toggle_LED_Demo.c
